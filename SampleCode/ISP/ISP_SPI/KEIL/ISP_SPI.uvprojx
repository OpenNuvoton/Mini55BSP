# Keil uVision project ISP_SPI.uvprojx, settings and files
target ISP_SPI (6190000::V6.19::ARMCLANG)
  device: Mini55LDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x45FF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Mini55_ISP_SPI
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  c define: TARGET_Mini55
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\Mini55Series\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4600
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --map --first='startup_Mini55Series_tiny.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../: startup_Mini55Series_tiny.s
  group User
    ../: main.c fmc_user.c isp_user.c targetdev.c spi_transfer.c
