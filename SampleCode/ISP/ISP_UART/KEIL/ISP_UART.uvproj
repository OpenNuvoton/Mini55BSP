# Keil uVision project ISP_UART.uvproj, settings and files
target ISP_UART (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Mini55LDE Nuvoton
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x45FF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Mini55_ISP_UART0_P12_P13
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\Mini55Series\Include;..\..\..\..\Library\StdDriver\inc
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4600
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --map --first='startup_Mini55Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini55Series/Source/: system_Mini55Series.c
    ../../../../Library/Device/Nuvoton/Mini55Series/Source/ARM/: startup_Mini55Series.s
  group User
    ../: main.c FMC_USER.c ISP_USER.c uart_transfer.c targetdev.c
