# Keil uVision project SPI_FIFO_Flash.uvproj, settings and files
target SPI_FIFO_Flash (ARM-ADS)
  device: Mini55LDE Nuvoton
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x45FF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: SPI_Flash
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\Mini55Series\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4600
  memory RVCT9: RAM 0x20000000 size 0x800
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini55Series/Source/: system_Mini55Series.c
    ../../../../Library/Device/Nuvoton/Mini55Series/Source/ARM/: startup_Mini55Series.s
  group Libraries
    ../../../../Library/StdDriver/src/: uart.c clk.c retarget.c spi.c sys.c
  group User
    ../: main.c
