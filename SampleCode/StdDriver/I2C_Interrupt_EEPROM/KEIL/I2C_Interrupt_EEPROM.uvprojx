# Keil uVision project I2C_Interrupt_EEPROM.uvprojx, settings and files
target I2C_Interrupt_EEPROM (6150000::V6.15::ARMCLANG)
  device: Mini55LDE Nuvoton
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x45FF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: I2C_Interrupt_EEPROM
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\Mini55Series\Include;..\..\..\..\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x4600
  memory RVCT9: RAM 0x20000000 size 0x800
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini55Series/Source/: system_Mini55Series.c
    ../../../../Library/Device/Nuvoton/Mini55Series/Source/ARM/: startup_Mini55Series.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c i2c.c sys.c uart.c retarget.c gpio.c
