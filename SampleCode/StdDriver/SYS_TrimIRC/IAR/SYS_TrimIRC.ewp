# IAR project SYS_TrimIRC.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Mini51DE series Nuvoton Mini51DE series (Mini51DE,Mini52DE,Mini54DE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\library\Device\Nuvoton\Mini55Series\Include; $PROJ_DIR$..\..\..\..\..\library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SYS_TrimIRC.bin
  ILINK.IlinkOutputFile: SYS_TrimIRC.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS Files
    ../../../../Library/Device/Nuvoton/Mini55Series/Source/IAR/: startup_Mini55Series.s
    ../../../../Library/Device/Nuvoton/Mini55Series/Source/: system_Mini55Series.c
  group Library Files
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c wdt.c
  group Source Files
    ../: main.c
